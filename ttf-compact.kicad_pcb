# Repository gingerologist/ttf-compact

## KiCad design ttf-compact.kicad_pcb

Schematic: ttf-compact.kicad_sch

Parts:
C1, C15, C32, C33, C55, C705: 1u,10%,25V; C_0402_1005Metric_for_0.25mm_grid; Manufacturer Part CL05A105KA5NQNC
C2, C18: 100n,10%,50V; C_0402_1005Metric_for_0.25mm_grid; Manufacturer Part CL05B104KB54PNC
C3, C4: 10n,10%,50V; C_0402_1005Metric_for_0.25mm_grid; Manufacturer Part CL05B103KB5NNNC
C5, C10: 18p,±5%,50V; C_0402_1005Metric_for_0.25mm_grid; Manufacturer Part 0402CG180J500NT
C6, C9, C11, C36, C37, C38, C50, C51, C52, C53, C54, C60: 100n,10%,16V; C_0402_1005Metric_for_0.25mm_grid; Manufacturer Part CL05B104KO5NNNC
C7, C8, C56, C57, C58, C59: 2.2u,20%,6.3V; C_0402_1005Metric_for_0.25mm_grid; Manufacturer Part CL05A225MQ5NSNC
C31: 100n,10%,50V; C_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part CC0603KRX7R9BB104
C700, C701, C702, C703: 10u,10%,50V; C_0805_2012Metric; Manufacturer Part GRM21BR61H106KE43L
D1, D7: GREEN; LED_0603_1608Metric; Manufacturer Part NCD0603G1
D2, D3, D4, D5, D6, D8: 3.3V,15p; D_SOD-923; Manufacturer Part ESD9B3.3ST5G
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.5mm_Pad_Via
J5, J999: USB_C_U262-161N-4BVC11; USB_C_Receptacle_XKB_U262-16XN-4BVC11; Manufacturer Part U262-161N-4BVC11
J8: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical; Manufacturer Part PZ254R-11-05P; not fitted
Q1: DTC143ZCA; SOT-23; Manufacturer Part DTC143ZCA
R1, R2: 10R,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF100JT5E
R4, R6, R7, R8, R10, R11, R18, R701: 10k,1%; R_0402_1005Metric_for_0.25mm_grid; Manufacturer Part 0402WGF1002TCE
R5: 6.8k,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF6801T5E
R9, R17: 33R,1%; R_0402_1005Metric_for_0.25mm_grid; Manufacturer Part 0402WGF330JTCE
R13, R14: 220R,0.1%; R_0402_1005Metric_for_0.25mm_grid; Manufacturer Part RT0402BRE07220RL
R31, R32: 22R,1%; R_0402_1005Metric_for_0.25mm_grid; Manufacturer Part 0402WGF220JTCE
R33, R35, R998, R999: 5.1k,1%; R_0402_1005Metric_for_0.25mm_grid; Manufacturer Part 0402WGF5101TCE
R36, R37: 0R,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF0000T5E
R40, R41, R42, R43, R44, R45: 100R,1%; R_0402_1005Metric_for_0.25mm_grid; Manufacturer Part 0402WGF1000TCE
R93, R94: 10k,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF1002T5E
R700, R702: 33k,1%; R_0402_1005Metric_for_0.25mm_grid; Manufacturer Part 0402WGF3302TCE
SW1: SW_DIP_x05; SW_DIP_SPSTx05_Slide_9.78x14.88mm_W7.62mm_P2.54mm; Manufacturer Part DS-05RP
SW999: OS102011MA1QN1; SW_Slide_SPDT_Angled_CK_OS102011MA1Q; Manufacturer Part OS102011MA1QN1
TP2, TP3, TP6, TP7, TP10, TP11, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP32, TP33, TP38: TestPoint; TestPoint_THTPad_D1.0mm_Drill0.5mm; not fitted
U4: STM32F405RGTx; LQFP-64_10x10mm_P0.5mm; Manufacturer Part STM32F405RGT6
U5: ESDA5V3L; SOT-23; Manufacturer Part ESDA5V3L
U6: CH340N; SO-8_3.9x4.9mm_P1.27mm; Manufacturer Part CH340N
U7: XC6206P332MR-G; SOT-23; Manufacturer Part XC6206P332MR-G
U11: AD9834BRUZ; TSSOP-20_4.4x6.5mm_P0.65mm; Manufacturer Part AD9834BRUZ-REEL
U13: REF3033; SOT-23; Manufacturer Part REF3033AIDBZR
U700: TPS2121RUXR; Texas_VQFN-HR-12_2x2.5mm_P0.5mm; Manufacturer Part TPS2121RUXR
Y1: 25MHz, 50ppm, 1.6-3.6V; Oscillator_SMD_SeikoEpson_SG210-4Pin_2.5x2.0mm; Manufacturer Part X1G0041710033

Connections:
+3V3: C9.1, C31.1, C33.1, C37.1, C50.1, C51.1, C52.1, C53.1, C56.1, C57.1, C58.1, C59.1, C60.1, J8.1, R6.1, TP2.1 (1_1), TP23.1 (1_1), U4.1 (VBAT), U4.19 (VDD), U4.32 (VDD), U4.48 (VDD), U4.64 (VDD), U6.5 (VCC), U6.8 (V3), U7.2 (VO), U11.5 (DVDD), Y1.1 (~ST), Y1.4 (Vcc); also elsewhere on the board
+3V3A: C4.1, C15.1, C38.1, C54.1, C55.1, TP38.1 (1_1), U4.13 (VDDA), U11.4 (AVDD), U13.2 (OUT)
+5V: C1.1, C6.1, C32.1, C702.1, C703.1, D1.2 (A), D7.2 (A), TP18.1 (1_1), U7.3 (VI), U13.1 (IN), U700.1 (OUT), U700.8 (OUT); also elsewhere on the board
/AMP_OUTA: R1.1; also elsewhere on the board
/AMP_OUTA1: R1.2; also elsewhere on the board
/AMP_OUTB: R2.1; also elsewhere on the board
/AMP_OUTB1: R2.2; also elsewhere on the board
/BOOT0: R8.1, TP3.1 (1_1), U4.60 (BOOT0)
/BOOT1: R7.1, TP24.1 (1_1), U4.28 (PB2)
/CH340_RX: R37.1, TP20.1 (1_1), U6.7 (RXD)
/CH340_TX: R36.1, TP19.1 (1_1), U6.6 (TXD)
/DAC_OUT1: R5.1, TP7.1 (1_1), U4.20 (PA4)
/DDS_CLK: R9.2, TP10.1 (1_1), U11.8 (MCLK)
/DDS_OUTA: C10.1, R14.1, TP14.1 (1_1), U11.20 (IOUTB); also elsewhere on the board
/DDS_OUTB: C5.1, R13.1, TP15.1 (1_1), U11.19 (IOUT); also elsewhere on the board
/DDS_RESET: R4.2, TP11.1 (1_1), U4.27 (PB1), U11.11 (RESET)
/DIP_SW1: D2.2 (A2), R40.2, SW1.10
/DIP_SW2: D3.2 (A2), R41.2, SW1.9
/DIP_SW3: D4.2 (A2), R42.2, SW1.8
/DIP_SW4: D5.2 (A2), R43.2, SW1.7
/DIP_SW5: D6.2 (A2), R44.2, SW1.6
/DM: J5.A7 (D-), J5.B7 (D-), R32.1, U5.1 (D+)
/DP: J5.A6 (D+), J5.B6 (D+), R31.1, U5.2 (D-)
/FS_ADJUST: C18.1, R5.2, U11.1 (FS_ADJUST)
/JTCK/SWCLK: J8.3, U4.49 (PA14)
/JTMS/SWDIO: J8.4, U4.46 (PA13)
/LED: Q1.3 (C), R94.2
/LEDC: Q1.1 (B), U4.26 (PB0)
/MUX1_CLK: U4.9 (PC1); also elsewhere on the board
/MUX1_CLR: U4.11 (PC3); also elsewhere on the board
/MUX1_DIN: U4.8 (PC0); also elsewhere on the board
/MUX1_LE_N: U4.10 (PC2); also elsewhere on the board
/NRST: C11.1, J8.2, R6.2, U4.7 (NRST)
/OSC_IN: R17.2, U4.5 (PH0)
/SPI2_MOSI: TP28.1 (1_1), U4.36 (PB15), U11.13 (SDATA)
/SPI2_NSS: TP26.1 (1_1), U4.33 (PB12), U11.15 (FSYNC)
/SPI2_SCK: TP27.1 (1_1), U4.34 (PB13), U11.14 (SCLK)
/SW1: R40.1, U4.21 (PA5)
/SW2: R41.1, U4.22 (PA6)
/SW3: R42.1, U4.23 (PA7)
/SW4: R43.1, U4.24 (PC4)
/SW5: R44.1, U4.25 (PC5)
/SW999: R45.1, U4.41 (PA8)
/USART_RX: R36.2, U4.43 (PA10)
/USART_TX: R37.2, U4.42 (PA9)
/USB_DM: R32.2, U6.2 (UD-)
/USB_DP: R31.2, U6.1 (UD+)
/VUSB1: C700.1, J999.A4 (VBUS), J999.A9 (VBUS), J999.B4 (VBUS), J999.B9 (VBUS), R700.1, U700.7 (IN1)
/VUSB2: C701.1, J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), U700.2 (IN2)
GND: C1.2, C2.1, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C15.2, C18.2, C31.2, C32.2, C33.2, C36.2, C37.2, C38.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C700.2, C701.2, C702.2, C703.2, C705.2, D2.1 (A1), D3.1 (A1), D4.1 (A1), D5.1 (A1), D6.1 (A1), D8.1 (A1), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.S1 (SHIELD), J8.5, J999.A1 (GND), J999.A12 (GND), J999.B1 (GND), J999.B12 (GND), J999.S1 (SHIELD), Q1.2 (E), R4.1, R7.2, R8.2, R10.1, R11.1, R13.2, R14.2, R18.1, R33.2, R35.2, R93.2, R701.2, R702.2, R998.2, R999.2, SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW999.2 (B), TP13.1 (1_1), TP16.1 (1_1), TP17.1 (1_1), TP21.1 (1_1), TP22.1 (1_1), TP25.1 (1_1), TP29.1 (1_1), TP32.1 (1_1), TP33.1 (1_1), U4.12 (VSSA), U4.18 (VSS), U4.63 (VSS), U5.3 (GND), U6.3 (GND), U7.1 (GND), U11.7 (DGND), U11.18 (AGND), U13.3 (GND), U700.3 (CP2), U700.4 (OV2), U700.5 (OV1), U700.12 (GND), Y1.2 (GND); also elsewhere on the board
unnamed: D1.1 (K), R93.1
unnamed: D7.1 (K), R94.1
unnamed: D8.2 (A2), R45.2, SW999.1 (A)
unnamed: J5.A5 (CC1), R35.1
unnamed: J5.B5 (CC2), R33.1
unnamed: J999.A5 (CC1), R998.1
unnamed: J999.B5 (CC2), R999.1
unnamed: C8.1, U4.31 (VCAP_1)
unnamed: C7.1, U4.47 (VCAP_2)
unnamed: C36.1, U11.6 (CAP/2.5V)
unnamed: C4.2, U11.3 (COMP)
unnamed: R18.2, U11.9 (FSELECT)
unnamed: R11.2, U11.10 (PSELECT)
unnamed: C3.1, U11.2 (REFOUT)
unnamed: R10.2, U11.12 (SLEEP)
unnamed: C2.2, U11.17 (VIN)
unnamed: R702.1, U700.10 (ILM)
unnamed: R700.2, R701.1, U700.6 (PR1)
unnamed: C705.1, U700.11 (SS)
unnamed: R9.1, R17.1, TP6.1 (1_1), Y1.3 (OUT)

Notes on the sheet:
XKB U262-161N-4BVC11 C319148
JTDI
parallel with 7.5k, we have 199.55ohm
DDS_RESET is active high
翠绿色，正向电压3.0V (2.6-3.6V)
JNTRST
JTDO
ECO 1. Chnage 5V->12V Power IC 2. Add two test points on opamp output 3. Add two ground test points 4. parallel R19 with R11, 1K || 15K => 937.5R hence gain = (18K + 937.5) / 937.5 = 20.2
2.2u + 0.1u for each vdd/vdda pin

Parts:
C601, C611, C621, C631: 10u,10%,50V; C_0805_2012Metric; Manufacturer Part GRM21BR61H106KE43L
C602, C603, C612, C622, C623, C632: 100n,10%,50V; C_0402_1005Metric_for_0.25mm_grid; Manufacturer Part CL05B104KB54PNC
C650, C652, C660, C662, C985, C986, C987: 1u,10%,25V; C_0402_1005Metric_for_0.25mm_grid; Manufacturer Part CL05A105KA5NQNC
C651, C653, C661, C663: 10p,5%,50V; C_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part CL10C100JB8NNNC
C654, C664, C668: 2.2u,10%,16V; C_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part CL10A225KO8NNNC
C667: 100n,10%,50V; C_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part CC0603KRX7R9BB104
D9, D10: BAV99,215; SOT-23; Manufacturer Part BAV99,215
D650, D660: BZX84-B36-QR; SOT-23; Manufacturer Part BZX84-B36-QR; not fitted
R601, R602, R611, R612, R621, R622, R631, R632: 33k,1%; R_0402_1005Metric_for_0.25mm_grid; Manufacturer Part 0402WGF3302TCE
R603, R613, R623, R633: 100R,1%; R_1206_3216Metric; Manufacturer Part 1206W4F1000T5E; not fitted
R651, R661: 953R,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part FRC0603F9530TS
R652, R662: 1k,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF1001T5E
R653, R663: 20k,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF2002T5E
R654, R664: 7.68k,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF7681T5E
R655, R665: 10k,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF1002T5E
R656, R666: 33k,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF3302T5E
R9650, R9660: 220R,1%; R_0805_2012Metric; Manufacturer Part RS-05K2200FT
TP8, TP9, TP12, TP30, TP36, TP37: TestPoint; TestPoint_THTPad_D1.0mm_Drill0.5mm; not fitted
U1: OPA2365AIDR; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer Part OPA2365AIDR
U2: TI REF2033AIDDCR; SOT-23-5; Manufacturer Part REF2033AIDDCR
U601, U611, U621, U631: BUF634AIDDA; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.71x3.4mm_Th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; Manufacturer Part BUF634AIDDAR
U650, U660: OPA892DR; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer Part OPA892DR

Connections:
+3.3VA: C667.1, C668.1, C987.1, TP37.1 (1_1), U1.8 (V+), U2.5 (Vref)
+5V: C985.1, U2.3 (EN), U2.4 (IN); also elsewhere on the board
+33V: C601.1, C602.2, C603.2, C621.1, C622.2, C623.2, D9.2 (K), R601.1, R621.1, TP8.1 (1_1), U601.7 (V+), U621.7 (V+)
+35V: D9.1 (A); also elsewhere on the board
-33V: C611.2, C612.1, C631.2, C632.1, D10.1 (A), R612.2, R613.2, R632.2, R633.2, TP30.1 (1_1), U611.4 (V-), U611.9 (EP(V-)), U631.4 (V-), U631.9 (EP(V-))
-35V: D10.2 (K); also elsewhere on the board
/AMP_OUTA: C651.2, R602.2, R611.1, R653.2, R9650.2; also elsewhere on the board
/AMP_OUTB: C661.2, R622.2, R631.1, R663.2, R9660.2; also elsewhere on the board
/DDS_OUTA: C652.1; also elsewhere on the board
/DDS_OUTB: C662.1; also elsewhere on the board
/amp/VAMP1+: D650.3 (K), U601.6, U650.7 (V+)
/amp/VAMP1-: D650.1 (A), U611.6, U650.4 (V-)
/amp/VAMP2+: D660.3 (K), U621.6, U660.7 (V+)
/amp/VAMP2-: D660.1 (A), U631.6, U660.4 (V-)
/amp/VBIAS: C654.1, C664.1, C986.1, R654.2, R655.1, R664.2, R665.1, TP36.1 (1_1), U2.1 (Vbias)
GND: C601.2, C602.1, C603.1, C611.1, C612.2, C621.2, C622.1, C623.1, C631.1, C632.2, C654.2, C664.2, C667.2, C668.2, C985.2, C986.2, C987.2, R603.2, R623.2, R651.1, R652.2, R661.1, R662.2, U1.4 (V-), U2.2 (GND), U601.4 (V-), U601.9 (EP(V-)), U611.7 (V+), U621.4 (V-), U621.9 (EP(V-)), U631.7 (V+); also elsewhere on the board
unnamed: C650.1, C653.2, R656.2, TP9.1 (1_1), U1.1
unnamed: C660.1, C663.2, R666.2, TP12.1 (1_1), U1.7
unnamed: C652.2, R654.1, U1.3 (+)
unnamed: C653.1, R655.2, R656.1, U1.2 (-)
unnamed: C662.2, R664.1, U1.5 (+)
unnamed: C663.1, R665.2, R666.1, U1.6 (-)
unnamed: R603.1, U601.1 (BW)
unnamed: R601.2, R602.1, U601.3 (V_{IN})
unnamed: R613.1, U611.1 (BW)
unnamed: R611.2, R612.1, U611.3 (V_{IN})
unnamed: R623.1, U621.1 (BW)
unnamed: R621.2, R622.1, U621.3 (V_{IN})
unnamed: R633.1, U631.1 (BW)
unnamed: R631.2, R632.1, U631.3 (V_{IN})
unnamed: C650.2, R651.2, U650.3 (+)
unnamed: C651.1, R652.1, R653.1, U650.2 (-)
unnamed: R9650.1, U650.6 (OUT)
unnamed: C660.2, R661.2, U660.3 (+)
unnamed: C661.1, R662.1, R663.1, U660.2 (-)
unnamed: R9660.1, U660.6 (OUT)

Parts:
C501: 1u,10%,50V; C_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part CL10A105KB8NNNC
C503, C504: 100n,10%,100V; C_0805_2012Metric; Manufacturer Part CL21B104KCFNNNE
J1: 1x16P,3.81mm; PhoenixContact_MC_1,5_16-G-3.81_1x16_P3.81mm_Horizontal_SS; Manufacturer Part WJ15EDGRC-3.81-16P-14-00A
R501: 100k,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF1003T5E
TP34, TP35: TestPoint; TestPoint_THTPad_D1.0mm_Drill0.5mm; not fitted
U501: HV2801K6-G; HV2801-QFN-64_EP_9x9_Pitch0.5mm_EP7x7mm; Manufacturer Part HV2801K6-G

Connections:
+3V3: C501.1, R501.1, U501.9 (VDD); also elsewhere on the board
+35V: C503.1, C504.1, U501.35 (VPP), U501.46 (VPP); also elsewhere on the board
-35V: C503.2, C504.2, U501.37 (VNN), U501.44 (VNN), U501.65 (VSUB); also elsewhere on the board
/AMP_OUTA1: TP34.1 (1_1), U501.3 (SW31), U501.16 (SW1), U501.19 (SW3), U501.22 (SW5), U501.25 (SW7), U501.28 (SW9), U501.31 (SW11), U501.34 (SW13), U501.40 (SW15), U501.43 (SW17), U501.49 (SW19), U501.52 (SW21), U501.55 (SW23), U501.58 (SW25), U501.61 (SW27), U501.64 (SW29); also elsewhere on the board
/AMP_OUTB1: TP35.1 (1_1), U501.1 (SW30), U501.14 (SW0), U501.17 (SW2), U501.20 (SW4), U501.23 (SW6), U501.26 (SW8), U501.29 (SW10), U501.32 (SW12), U501.38 (SW14), U501.41 (SW16), U501.47 (SW18), U501.50 (SW20), U501.53 (SW22), U501.56 (SW24), U501.59 (SW26), U501.62 (SW28); also elsewhere on the board
/MUX1_CLK: U501.8 (CLK); also elsewhere on the board
/MUX1_CLR: R501.2, U501.5 (CLR); also elsewhere on the board
/MUX1_DIN: U501.10 (DIN); also elsewhere on the board
/MUX1_LE_N: U501.7 (~LE); also elsewhere on the board
/mux1/Y01: J1.1, U501.15 (Y01)
/mux1/Y23: J1.2, U501.18 (Y23)
/mux1/Y45: J1.3, U501.21 (Y45)
/mux1/Y67: J1.4, U501.24 (Y67)
/mux1/Y89: J1.5, U501.27 (Y89)
/mux1/Y1011: J1.6, U501.30 (Y1011)
/mux1/Y1213: J1.7, U501.33 (Y1213)
/mux1/Y1415: J1.8, U501.39 (Y1415)
/mux1/Y1617: J1.9, U501.42 (Y1617)
/mux1/Y1819: J1.10, U501.48 (Y1819)
/mux1/Y2021: J1.11, U501.51 (Y2021)
/mux1/Y2223: J1.12, U501.54 (Y2223)
/mux1/Y2425: J1.13, U501.57 (Y2425)
/mux1/Y2627: J1.14, U501.60 (Y2627)
/mux1/Y2829: J1.15, U501.63 (Y2829)
/mux1/Y3031: J1.16, U501.2 (Y3031)
GND: C501.2, U501.11 (GND); also elsewhere on the board

Notes on the sheet:
TABLE 2-1, VSUB must be connected ot VNN!!!

Parts:
C301, C304, C400, C403, C404, C406: 10u,10%,50V; C_0805_2012Metric; Manufacturer Part GRM21BR61H106KE43L
C302: 15n,10%,50V; C_0603_1608Metric; Manufacturer Part FCC0603B153K500CT
C303: 2.2u,10%,50V; C_0805_2012Metric; Manufacturer Part CL21A225KBQNNNE
C401: 10u,10%,100V; C_1210_3225Metric; Manufacturer Part FS32X106K101EGG
C402: 100n,10%,100V; C_0805_2012Metric; Manufacturer Part CL21B104KCFNNNE
C405: 100n,10%,50V; C_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part CC0603KRX7R9BB104
D301: 100V,2A; D_SOD-123F; Manufacturer Part DSS210
L301: 12uH,20%,1.7A; L_Sunlord_SWPA4030S; Manufacturer Part SWPA4030S120MT
L401: 33uH,20%,4.8A; L_Sunlord_MWSA1004S; Manufacturer Part MWSA1004S-330MT
R301: 86.6k,1%; R_0603_1608Metric; Manufacturer Part FRC0603F8662TS
R302: 287k,1%; R_0603_1608Metric; Manufacturer Part FRC0603F2873TS
R303: 10.5k,1%; R_0603_1608Metric; Manufacturer Part FRC0603F1052TS
R401: 64.9k,1%; R_0603_1608Metric; Manufacturer Part FRC0603F6492TS
R402: 340k,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part FRC0603F3403TS
R403: 10k,1%; R_0603_1608Metric_1.28x0.64mm_Courtyard; Manufacturer Part 0603WAF1002T5E
TP4, TP5: TestPoint; TestPoint_THTPad_D1.0mm_Drill0.5mm; not fitted
U302: TI TPS61170DRVR; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; Manufacturer Part TPS61170DRVR
U401: LMR38020FDDAR; TI_SO-PowerPAD-8; Manufacturer Part LMR38020FDDAR

Connections:
+5V: C301.1, C400.1, C401.1, C402.1, L301.1, U302.5 (CTRL), U302.6 (VIN), U401.2 (EN), U401.3 (VIN); also elsewhere on the board
+35V: C303.1, C304.1, D301.1 (K), R302.1, TP4.1 (1_1); also elsewhere on the board
-35V: C401.2, C402.2, C403.2, C404.2, C406.2, R401.2, R403.2, TP5.1 (1_1), U401.1 (GND), U401.9 (EP); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, C400.2, C403.1, C404.1, C406.1, L401.2, R303.2, R402.1, U302.3 (GND), U302.7 (EP); also elsewhere on the board
unnamed: C302.1, R301.2
unnamed: D301.2 (A), L301.2, U302.4 (SW)
unnamed: R301.1, U302.2 (COMP)
unnamed: R302.2, R303.1, U302.1 (FB)
unnamed: C405.1, U401.7 (BOOT)
unnamed: R402.2, R403.1, U401.5 (FB)
unnamed: R401.1, U401.4 (RT/SYNC)
unnamed: C405.2, L401.1, U401.8 (SW)

Notes on the sheet:
68uH MWSA1004S-680MT C408492 for LMR38010S
ECO：可以修改R302阻值到271k,1%，得到33V电压。
actual voltage <60V
R402 can be changed to 316kOhm for 33V output.
33uH MWSA1004S-330MT C408490 for LMR38020F
C401 larger than required (4.7uF)
